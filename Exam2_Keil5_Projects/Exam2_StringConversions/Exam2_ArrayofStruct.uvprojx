# Keil uVision project Exam2_ArrayofStruct.uvprojx, settings and files
target Exam2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Exam2
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --C99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source code
    ./: Startup.s Exam2asm.s Exam2CPart.c
  group Object code
    ./: pll.o uart.o exam2stringconversions.o
software components: CMSIS:CORE 5.0.2
